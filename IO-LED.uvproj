# Keil uVision project IO-LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: IO-LED +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c timer.c timeResolv.c timerTask.c debug.c
    ./: uart.c
  group header
    ./: config.h delay.h STC15Fxxxx.H uart.h
